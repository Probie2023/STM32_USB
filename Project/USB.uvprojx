# Keil uVision project USB.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC2)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\include;..\User\usart;..\User;..\User\usb\core;..\User\usb\dwc2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/start/: startup_stm32f10x_hd.s
  group INC
    ../Libraries/include/: core_cm3.h misc.h stm32f10x.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_usart.h
  group SOUR
    ../Libraries/source/: core_cm3.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c system_stm32f10x.c
  group USER
    ../User/usart/: bsp_usart.c bsp_usart.h
    ../User/: main.c main.h
  group USB
    ../User/usb/core/: usb.c usb.h
  group DWC2
    ../User/usb/dwc2/: core.c core.h
